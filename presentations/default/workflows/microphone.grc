# the microphone, in stereo: the last two seconds of both channels on a symmetric log axis, one second around each
# clap a Schmitt trigger catches, and the left channel's spectrum over its waterfall. 96 kS/s, for ultrasound up to
# 48 kHz where the sound card delivers it; a card that cannot gives its own rate, which the source's first tag carries.
# The time chart draws the minimum and maximum of every 96 samples, so its envelope holds every one; the triggered
# chart and the spectrum see every sample.
blocks:
  - id: gr::audio::AudioSource<float32>
    parameters:
      name: microphone
      sample_rate: 96000
      num_channels: 2
  - id: gr::present::blocks::Deinterleave<float32>
    parameters:
      name: channels
      n_channels: 2
  - id: gr::present::blocks::PeakDecimator<float32>
    parameters:
      name: peaksL
      block_size: 96 # the time chart draws each block's minimum and maximum: 2000 samples a second
  - id: gr::present::blocks::PeakDecimator<float32>
    parameters:
      name: peaksR
      block_size: 96
  - id: gr::blocks::trigger::SchmittTriggerNoInterpolation<float32>
    parameters:
      name: triggerL
      threshold: 0.1
  - id: gr::blocks::trigger::SchmittTriggerNoInterpolation<float32>
    parameters:
      name: triggerR
      threshold: 0.1
  - id: gr::basic::StreamToDataSet<float32>
    parameters:
      name: snapshotL
      filter: RISING
      n_pre: 4800
      n_post: 43200
      holdoff_samples: 48000 # a clap rings across the threshold: one snapshot, then deaf for 0.5 s at 96 kS/s
  - id: gr::basic::StreamToDataSet<float32>
    parameters:
      name: snapshotR
      filter: RISING
      n_pre: 4800
      n_post: 43200
      holdoff_samples: 48000 # a clap rings across the threshold: one snapshot, then deaf for 0.5 s at 96 kS/s
  - id: gr::blocks::fft::FFT<float32, gr::DataSet<float32>>
    parameters:
      name: FFT
      fft_size: 8192
      sample_rate: 96000
      output_in_db: true
      signal_name: microphone L
  - id: opendigitizer::ImPlotSink<float32>
    parameters:
      name: lastL
      signal_name: L
      signal_unit: FS
      required_size: 4000
  - id: opendigitizer::ImPlotSink<float32>
    parameters:
      name: lastR
      signal_name: R
      signal_unit: FS
      required_size: 4000
  - id: opendigitizer::ImPlotSink<gr::DataSet<float32>>
    parameters:
      name: clapL
      dataset_index: 0
      signal_name: L, triggered
      signal_unit: FS
      n_history: 1
  - id: opendigitizer::ImPlotSink<gr::DataSet<float32>>
    parameters:
      name: clapR
      dataset_index: 0
      signal_name: R, triggered
      signal_unit: FS
      n_history: 1
  - id: opendigitizer::ImPlotSink<gr::DataSet<float32>>
    parameters:
      name: audioSink
      dataset_index: 0
      signal_name: microphone L
      abscissa_quantity: frequency
      abscissa_unit: Hz
      signal_quantity: magnitude
      signal_unit: dB
  - id: DigitizerUi::ImControlNumber
    parameters:
      name: threshold
      label: threshold
      unit: FS
      value_type: float32
      value: 0.1
      min: 0
      max: 1
      step: 0.01
      style: slider
      target_map: "triggerL,triggerR:threshold"
  - id: DigitizerUi::ImControlNumber
    parameters:
      name: holdOff
      label: hold-off
      unit: samples
      value_type: uint32
      value: 48000
      min: 0
      max: 192000
      step: 4000
      style: slider
      target_map: "snapshotL,snapshotR:holdoff_samples"
connections:
  - [ microphone, 0, channels, 0 ]
  - [ channels, [0, 0], triggerL, 0 ]
  - [ channels, [0, 1], triggerR, 0 ]
  - [ triggerL, 0, snapshotL, 0 ]
  - [ triggerR, 0, snapshotR, 0 ]
  - [ snapshotL, 0, clapL, 0 ]
  - [ snapshotR, 0, clapR, 0 ]
  - [ channels, [0, 0], FFT, 0 ]
  - [ FFT, 0, audioSink, 0 ]
  - [ channels, [0, 0], peaksL, 0 ]
  - [ peaksL, 0, lastL, 0 ]
  - [ channels, [0, 1], peaksR, 0 ]
  - [ peaksR, 0, lastR, 0 ]
dashboard:
  layout: Free
  windowLayout:
    floatingWindows: { }
    dockSpace:
      vsplit:
        first:
          hsplit:
            first: "Last 2 s"
            second: "Triggered"
            ratio: !!float32 0.5
        second: "Audio Spectrum"
        ratio: !!float32 0.62 # the spectrum's share: in a vsplit the ratio goes to the bottom pane
  sources:
    - name: lastL
      block: lastL
    - name: lastR
      block: lastR
    - name: clapL
      block: clapL
    - name: clapR
      block: clapR
    - name: audioSink
      block: audioSink
  plots:
    - name: Last 2 s
      type: XYChart
      parameters:
        show_legend: true
        history_seconds: 2 # at the rate the device delivers; n_history follows
        n_history: 4000 # until the rate is known: 2 s of minimum-maximum pairs at 2000 a second
      axes:
        - axis: Y
          min: -1
          max: 1
          scale: SymLog
          linear_threshold: 0.001 # linear within ±1 mFS (-60 dBFS), logarithmic beyond
      sources:
        - lastL
        - lastR
    - name: Triggered
      type: XYChart
      parameters:
        show_legend: true
        show_tags: false # the clap's every threshold crossing would hide the trace
        n_history: 48000 # samples: one snapshot, 0.5 s at 96 kS/s
        max_history_count: 1
      axes:
        - axis: X
          min: -0.05
          max: 0.45
        - axis: Y
          min: -1
          max: 1
      sources:
        - clapL
        - clapR
    - name: Audio Spectrum
      type: opendigitizer::charts::SpectrumView
      parameters:
        show_max_hold: true
        show_average: true
        decay_tau_frames: 60
        n_history: 256
        colormap: ImPlotColormap_Viridis
        top_pane_ratio: 0.5
      axes:
        - axis: X
          min: 0
          max: NaN
          scale: Linear
          format: MetricInline
        - axis: Y
          min: -120
          max: -20
        - axis: Z
          min: -110
          max: -30
      sources:
        - audioSink
