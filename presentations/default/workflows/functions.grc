# extracted from OpenDigitizer's assets/sampleDashboards/DemoDashboard.grc
blocks:
  - id: gr::basic::ClockSource
    parameters:
      name: ClockSource
      chunk_size: 40
      do_zero_order_hold: true
      n_samples_max: 0
      repeat_period: 4000000000
      sample_rate: 1000
      verbose_console: false
      tag_times: !!uint64
        - 10000000
        - 100000000 # start pre-ramp
        - 200000000 # lower-plateau
        - 500000000 # start main-ramp
        - 1000000000 # upper-plateau
        - 2000000000 # CMD_DIAG_TRIGGER1
        - 3000000000 # start ramp-down
        - 3900000000
      tag_values: !!str
        - "CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=1"
        - "CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=2" # start pre-ramp
        - "CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=3" # lower-plateau
        - "CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=4" # start main-ramp
        - "CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=5" # upper-plateau
        - "CMD_DIAG_TRIGGER1"
        - "CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=6" # start ramp-down
        - "CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=7"
  - id: gr::basic::FunctionGenerator<float32>
    parameters:
      name: DipoleCurrentGenerator
      sample_rate: 1000
      signal_type: Const
      start_value: 0
      signal_trigger: "CMD_BP_START"
    ctx_parameters:
      - gr:context: "FAIR.SELECTOR.C=1:S=1:P=1"
        gr:ctx_time: !!uint64 0
        parameters:
          start_value: 100
          sample_rate: 1000
          signal_type: Const
      - gr:context: "FAIR.SELECTOR.C=1:S=1:P=2"  # start pre-ramp
        gr:ctx_time: !!uint64 0
        parameters:
          duration: 0.1
          start_value: 100
          final_value: 500
          round_off_time: 0.02
          sample_rate: 1000
          signal_type: ParabolicRamp
      - gr:context: "FAIR.SELECTOR.C=1:S=1:P=3"  # lower-plateau
        gr:ctx_time: !!uint64 0
        parameters:
          start_value: 500
          sample_rate: 1000
          signal_type: Const
      - gr:context: "FAIR.SELECTOR.C=1:S=1:P=4" # start main-ramp
        gr:ctx_time: !!uint64 0
        parameters:
          duration: 0.5
          start_value: 500
          final_value: 3000
          round_off_time: 0.2
          sample_rate: 1000
          signal_type: ParabolicRamp
      - gr:context: "FAIR.SELECTOR.C=1:S=1:P=5" # upper-plateau
        gr:ctx_time: !!uint64 0
        parameters:
          start_value: 3000
          sample_rate: 1000
          signal_type: Const
      - gr:context: "FAIR.SELECTOR.C=1:S=1:P=6" # start ramp-down
        gr:ctx_time: !!uint64 0
        parameters:
          duration: 0.3
          start_value: 3000
          final_value: 100
          sample_rate: 1000
          signal_type: CubicSpline
      - gr:context: "FAIR.SELECTOR.C=1:S=1:P=7" # upper-plateau
        gr:ctx_time: !!uint64 0
        parameters:
          start_value: 100
          sample_rate: 1000
          signal_type: Const
  - id: gr::basic::FunctionGenerator<float32>
    parameters:
      name: IntensityGenerator
      sample_rate: 1000
      signal_type: Const
      start_value: 0
      signal_trigger: "CMD_BP_START"
    ctx_parameters:
      - gr:context: "FAIR.SELECTOR.C=1:S=1:P=3" # lower-plateau
        gr:ctx_time: !!uint64 0
        parameters:
          start_value: !!float32 40e9
          sample_rate: 1000
          signal_type: Const
      - gr:context: "FAIR.SELECTOR.C=1:S=1:P=4" # start main-ramp
        gr:ctx_time: !!uint64 0
        parameters:
          duration: 0.500000
          start_value: !!float32 40e9
          final_value: !!float32 38e9
          sample_rate: 1000
          signal_type: CubicSpline
      - gr:context: "FAIR.SELECTOR.C=1:S=1:P=5"
        gr:ctx_time: !!uint64 0
        parameters:
          duration: 2
          start_value: !!float32 38e9
          final_value: !!float32 0
          round_off_time: 0.3
          sample_rate: 1000
          signal_type: ParabolicRamp
      - gr:context: "FAIR.SELECTOR.C=1:S=1:P=6"
        gr:ctx_time: !!uint64 0
        parameters:
          start_value: 0
          sample_rate: 1000
          signal_type: Const
  - id: opendigitizer::ImPlotSink<float32>
    parameters:
      name: DipoleCurrentSink
      required_size: 16384
      signal_name: dipole current
      signal_quantity: DipoleCurrent
      signal_unit: A
  - id: opendigitizer::ImPlotSink<float32>
    parameters:
      name: IntensitySink
      required_size: 16384
      signal_name: beam intensity
      signal_quantity: BeamIntensity
      signal_unit: ppp
connections:
  - [ ClockSource, 0, DipoleCurrentGenerator, 0 ]
  - [ DipoleCurrentGenerator, 0, DipoleCurrentSink, 0 ]
  - [ ClockSource, 0, IntensityGenerator, 0 ]
  - [ IntensityGenerator, 0, IntensitySink, 0 ]
dashboard:
  layout: Free
  windowLayout:
    floatingWindows: { }
    dockSpace: Function Generators
  sources:
    - name: IntensitySink
      block: IntensitySink
      port: 0
    - name: DipoleCurrentSink
      block: DipoleCurrentSink
      port: 0
  plots:
    - name: Function Generators
      parameters:
        n_history: 10000 # number of samples to plot
      axes:
        - axis: X
          min: NaN # auto-range min
          max: NaN # auto-range max
          scale: Time # UTC time axis, other options: Linear, LinearReverse, Time, Log10, SymLog
        - axis: Y
          min: NaN # enables auto-range for first axis
          max: NaN # enables auto-range for first axis
        - axis: Y
          min: -100. # second axis min
          max: NaN # second axis max
          format: Metric # options: Auto, Metric, MetricInline, Scientific, None, Default
      sources:
        - IntensitySink
        - DipoleCurrentSink
